# Autodesk Inventor assembly: Hubgetriebetest
## iProperties
Created: 2008-10
Part Number: Hubgetriebetest
Document SubType Name: Assembly
Designer: nkrapf
Author: nkrapf
